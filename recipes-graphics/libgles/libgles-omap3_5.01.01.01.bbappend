COMPATIBLE_MACHINE = "overo|pepper"
# Counteract meta-ti's preference for 4.05.00.03
DEFAULT_PREFERENCE_overo = "100"

INSANE_SKIP_${PN} += "already-stripped"
